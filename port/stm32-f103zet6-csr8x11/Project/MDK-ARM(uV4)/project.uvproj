# Keil uVision project project.uvproj, settings and files
target Flash (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F103ZE STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: output +hex
  AfterMake: CopyHex_Flash.bat
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_HD,NDEBUG
  c misc: --diag_suppress=870
  c include: ..\..\Libraries\CMSIS\Device\ST\STM32F10x\Include;..\..\Libraries\STM32F10x_StdPeriph_Driver\inc;..\..\User\bsp;..\..\User\bsp\inc;..\..\User;..\..\Libraries\CMSIS\Include;..\..\FreeRTOS\include;..\..\FreeRTOS\portable\RVDS\ARM_CM3;..\..\Middleware\ut_manager\Cunit\Headers;..\..\Middleware\ut_manager\Cunit\interface;..\..\Middleware\at_command;..\..\..\..\src;..\..\..\..\src\ble\gatt-service;..\..\..\..\src\ble;..\..\Libraries\CMSIS\Include;..\..\Libraries\CMSIS\Device\ST\STM32F10x\Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group User
    ../../User/: main.c includes.h FreeRTOSConfig.h
  group BSP
    ../../User/bsp/: bsp.c bsp.h
    ../../User/bsp/src/: bsp_key.c bsp_led.c bsp_uart_fifo.c
  group MDK-ARM
    ../../Libraries/CMSIS/Device/ST/STM32F10x/Source/Templates/arm/: startup_stm32f10x_hd.s
  group StdPeriph_Driver
    ../../User/bsp/: stm32f10x_it.c stm32f10x_assert.c
    ../../Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c stm32f10x_flash.c
  group CMSIS
    ../../User/bsp/: system_stm32f10x.c
  group FreeRTOS/Source
    ../../FreeRTOS/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
  group FreeRTOS/Ports
    ../../FreeRTOS/portable/RVDS/ARM_CM3/: port.c portmacro.h
    ../../FreeRTOS/portable/MemMang/: heap_4.c
  group Cunit
    ../../Middleware/ut_manager/Cunit/Sources/Basic/: Basic.c
    ../../Middleware/ut_manager/Cunit/Sources/Framework/: CUError.c MyMem.c TestDB.c TestRun.c Util.c
    ../../Middleware/ut_manager/Cunit/Sources/: Misc.c
    ../../Middleware/ut_manager/Cunit/interface/: cunit_interface.c
  group ATCommand
    ../../Middleware/at_command/: at_command.c at_command_bt.c
